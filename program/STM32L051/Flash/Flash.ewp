# IAR project Flash.ewp, settings and files
configuration flash (ARM, debug)
  General.OGChipSelectEditMenu: STM32L051x8 ST STM32L051x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L051xx
  ICCARM.CCIncludePath2: ../source/src; ../source/Drivers/STM32L0xx_HAL_Driver/Inc; ../source/Drivers/STM32L0xx_HAL_Driver/Inc/Legacy; ../source/Drivers/CMSIS/Include; ../source/Drivers/CMSIS/Device/ST/STM32L0xx/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: flash.out
  ILINK.IlinkIcfFile: stm32l051xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: main.c
    ../source/Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/iar/: startup_stm32l051xx.s
    ../source/Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c
