# IAR project relay.ewp, settings and files
configuration relay (ARM, debug)
  General.OGChipSelectEditMenu: STM32L051x8 ST STM32L051x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L051xx; USE_BAND_433
  ICCARM.CCDiagSuppress: pe188
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Include; ../Drivers/CMSIS/Device/ST/STM32L0xx/Include; ..\Drivers\STM32F0xx_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: relay.out
  ILINK.IlinkIcfFile: stm32l051xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../Inc/: interface.h
    ../Src/: main.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c
    ../Src/: stm32l0xx_hal_msp.c
  group Drivers/User
    ../Inc/: common.h delay.h gpio.h SX1276.H system.h usart.h
    ../Src/: delay.c gpio.c stm32l0xx_it.c SX1276.C system.c usart.c
  group EWARM
    ../Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/iar/: startup_stm32l051xx.s
  group Schdule
    ../Src/: mac.c ProcessEvent.c schdule.c
    ../Inc/: mac.h ProcessEvent.h schdule.h
