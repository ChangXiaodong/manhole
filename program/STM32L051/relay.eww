<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Flash\Flash.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\relay.ewp</path>
  </project>
  <batchBuild/>
</workspace>


