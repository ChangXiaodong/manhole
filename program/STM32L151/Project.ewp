# IAR project Project.ewp, settings and files
configuration Relay (ARM, debug)
  General.OGChipSelectEditMenu: STM32L151x8 ST STM32L151x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_MD; USE_BAND_433
  ICCARM.CCDiagSuppress: pe188
  ICCARM.CCIncludePath2: Sources\STM32L1xx_StdPeriph_Driver\inc; Sources\STM32L1xx_StdPeriph_Driver\CMSIS\Include; Sources\STM32L1xx_StdPeriph_Driver\CMSIS\Device\ST\STM32L1xx\Include; Sources; Sources\Drivers; Sources\Schdule
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: STM32L152-EVAL.out
  ILINK.IlinkIcfFile: stm32l1xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    Sources/: common.h
    Sources/Schdule/: interface.h
    ./: main.c
  group Drivers
    Sources/Drivers/: delay.c delay.h gpio.c gpio.h gsm.c gsm.h SX1276.C SX1276.H uart.c uart.h Xbee.c Xbee.h
  group Drivers/CMSIS
    Sources/: system_stm32l1xx.c
  group Drivers/EWARM
    Sources/EWARM/: startup_stm32l1xx_md.s
  group Drivers/StdPeriph_Driver
    Sources/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group Schdule
    Sources/Schdule/: mac.c mac.h ProcessEvent.c ProcessEvent.h schdule.c schdule.h stm32l1xx_it.c stm32l1xx_it.h
