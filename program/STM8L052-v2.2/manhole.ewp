# IAR project manhole.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L052R8 STM8L052R8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L05X_LD_VL; USE_BAND_433
  ICCSTM8.CCDiagSuppress: pa082,pe188
  ICCSTM8.CCIncludePath2: ; Libraries\hardware; Libraries\inc; Libraries\schdule
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: manhole.srec
  ILINK.IlinkOutputFile: manhole.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: common.h interface.h main.c
  group Drivers
    Libraries/src/: stm8l15x_adc.c stm8l15x_aes.c stm8l15x_beep.c stm8l15x_clk.c stm8l15x_comp.c stm8l15x_dac.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_irtim.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wfe.c stm8l15x_wwdg.c
  group Hardware
    Libraries/hardware/: delay.c delay.h mpu6050.c mpu6050.h spi.c spi.h SX1276.C SX1276.H system.c system.h
  group Schdule
    Libraries/schdule/: mac.c mac.h ProcessEvent.c ProcessEvent.h schdule.c schdule.h
    ./: stm8l15x_it.c
